options:
  parameters:
    author: Ralf DL5EU
    description: DVB-T reception with low bandwidth on 70cm using an RTL-SDR stick
    generate_options: qt_gui
    id: dvbt_rx_rtlsdr_ext
    output_language: python
    title: DVB-T RX with low bandwidth on 70cm
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 1
    label: Center freq.
    min_len: '0'
    rangeType: int
    start: '430000000'
    step: '100'
    stop: '440000000'
    value: conf_center_freq
    widget: counter
  states: {}
- name: conf_center_freq
  id: variable_config
  parameters:
    config_file: config.ini
    option: center_freq
    section: setup
    type: int
    value: '437000000'
    writeback: center_freq
  states: {}
- name: conf_decim_select
  id: variable_config
  parameters:
    config_file: config.ini
    option: decim_select
    section: setup
    type: int
    value: '1'
    writeback: decim_select
  states: {}
- name: conf_freq_corr_ppm
  id: variable_config
  parameters:
    config_file: config.ini
    option: freq_corr_ppm
    section: setup
    type: int
    value: '0'
    writeback: freq_corr_ppm
  states: {}
- name: conf_if_gain_db
  id: variable_config
  parameters:
    config_file: config.ini
    option: if_gain_db
    section: setup
    type: int
    value: '10'
    writeback: if_gain_db
  states: {}
- name: conf_rf_gain_db
  id: variable_config
  parameters:
    config_file: config.ini
    option: rf_gain_db
    section: setup
    type: int
    value: '10'
    writeback: rf_gain_db
  states: {}
- name: decim_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 7, 0, 1, 1
    label: Bandwidth
    labels: bandwidth_decim_factor.labels()
    num_opts: '0'
    options: bandwidth_decim_factor.indices()
    type: int
    value: conf_decim_select
  states: {}
- name: freq_corr_ppm
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 1, 1, 1
    label: Freq. ppm
    min_len: '0'
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: conf_freq_corr_ppm
    widget: counter
  states: {}
- name: if_gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 1, 1, 1
    label: IF gain
    min_len: '0'
    rangeType: int
    start: '0'
    step: '1'
    stop: '40'
    value: conf_if_gain_db
    widget: counter
  states: {}
- name: rf_gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    label: RF gain
    min_len: '0'
    rangeType: int
    start: '0'
    step: '1'
    stop: '42'
    value: conf_rf_gain_db
    widget: counter
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-200'
    step: '1'
    stop: '200'
    value: '-60'
    widget: counter
  states: {}
- name: sync_sample_rate
  id: variable
  parameters:
    value: bandwidth_decim_factor.sample_rate(decim_select)
  states: {}
- name: bandwidth_decim_factor
  id: epy_module
  parameters:
    source_code: |-
      # Central receiver-bandwidth configuration. Edit only these entries when
      # changing the available bandwidths; update the matching GRC resampler ports.
      PLUTO_SAMPLE_RATE = 2400000
      BANDWIDTHS = (
          ("2 MHz", 20, 21),
          ("1 MHz", 10, 21),
          ("500 kHz", 5, 21),
          ("333 kHz", 160, 1009),
          ("250 kHz", 5, 42),
          ("125 kHz", 5, 84),
          ("66 kHz", 280, 8909),
      )


      def interpolation(index):
          return BANDWIDTHS[int(index)][1]


      def decimation(index):
          return BANDWIDTHS[int(index)][2]


      def sample_rate(index):
          return PLUTO_SAMPLE_RATE * interpolation(index) / decimation(index)


      def labels():
          return [entry[0] for entry in BANDWIDTHS]


      def indices():
          return list(range(len(BANDWIDTHS)))
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\Projekte\GNURadio\video_rs.ts
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '1705'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '7'
    output_index: decim_select
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: decim_select
    num_inputs: '7'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1705'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: byte
  states: {}
- name: blocks_vector_to_stream_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: complex
  states: {}
- name: dl5eu_dvbt_energy_descramble_0
  id: dl5eu_dvbt_energy_descramble
  parameters:
    nsize: '8'
  states: {}
- name: dl5eu_dvbt_ofdm_synchronization_0
  id: dl5eu_dvbt_ofdm_synchronization
  parameters:
    diagnostics: 'False'
    guard_interval: GI_1_32
    interpolate: 'True'
    sample_rate: '1142857.143'
    snr: '10'
    squelch_db: squelch_threshold
    transmission_mode: T2k
  states: {}
- name: dl5eu_dvbt_reed_solomon_dec_0
  id: dl5eu_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    diagnostics: 'False'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dl5eu_dvbt_tps_decoder_0
  id: dl5eu_dvbt_tps_decoder
  parameters:
    print_tps_data: 'True'
    show_ports: 'True'
    transmission_mode: T2k
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C2_3
    constellation: 16qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_mpeg_ts_monitor_0
  id: dl5eu_mpeg_ts_monitor
  parameters:
    console_events: 'False'
    console_statistics: 'False'
    log_filename: D:\Projekte\GNURadio\ts_monitor_rs.csv
    log_interval_ms: '1000'
  states: {}
- name: dtv_dvbt_bit_inner_deinterleaver_0
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    constellation: 16qam
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_convolutional_deinterleaver_0
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_demap_0
  id: dtv_dvbt_demap
  parameters:
    constellation: 16qam
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Deinterleave
    transmission_mode: T2k
  states: {}
- name: freq_error
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 5,0,1,2
    label1: Freq. error (Hz)
    max: '10000'
    min: '-10000'
    name: ''
    type: float
    update_time: '0.25'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2400000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: rf_gain_db
    quadrature: 'True'
    rfdc: 'True'
    samplerate: bandwidth_decim_factor.PLUTO_SAMPLE_RATE
    type: fc32
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 230.0.0.1
    header: '0'
    payloadsize: '1316'
    port: '2000'
    send_eof: 'True'
    type: byte
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0,offset_tune=0,tuner_xtal=28.8e6,rtl_xtal=28.8e6
    bb_gain0: '20'
    bw0: '1200000'
    corr0: freq_corr_ppm
    freq0: center_freq
    gain0: rf_gain_db
    gain_mode0: 'False'
    if_gain0: if_gain_db
    sample_rate: '1200000'
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0, 0, 1, 2
    label1: '" "'
    name: Constellation
    size: '512'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0, 0, 1, 2
    label1: '" "'
    name: OFDM signal
    size: '512'
    type: complex
    update_time: '0.1'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '2400000'
    fc: '0'
    fftsize: '2048'
    gui_hint: 1, 2, 8, 1
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(0)
    interp: bandwidth_decim_factor.interpolation(0)
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(1)
    interp: bandwidth_decim_factor.interpolation(1)
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(2)
    interp: bandwidth_decim_factor.interpolation(2)
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(3)
    interp: bandwidth_decim_factor.interpolation(3)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(4)
    interp: bandwidth_decim_factor.interpolation(4)
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_0
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(6)
    interp: bandwidth_decim_factor.interpolation(6)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_4
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(5)
    interp: bandwidth_decim_factor.interpolation(5)
    type: ccc
  states: {}
- name: samp_error
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 6,0,1,2
    label1: Samp. error (ppm)
    max: '100'
    min: '-100'
    name: ''
    type: float
    update_time: '0.25'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: received_samples
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: received_samples
  states: {}

connections:
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_1, '0']
- [blocks_selector_0, '2', rational_resampler_xxx_2, '0']
- [blocks_selector_0, '3', rational_resampler_xxx_2_0, '0']
- [blocks_selector_0, '4', rational_resampler_xxx_3, '0']
- [blocks_selector_0, '5', rational_resampler_xxx_4, '0']
- [blocks_selector_0, '6', rational_resampler_xxx_3_0, '0']
- [blocks_selector_1, '0', virtual_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_1, '0', dl5eu_dvbt_viterbi_decoder_0, '0']
- [blocks_vector_to_stream_2_0, '0', qtgui_const_sink_x_0, '0']
- [dl5eu_dvbt_energy_descramble_0, '0', dl5eu_mpeg_ts_monitor_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '0', blocks_vector_to_stream_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '0', dl5eu_dvbt_tps_decoder_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '1', blocks_null_sink_0_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '2', freq_error, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '3', samp_error, '0']
- [dl5eu_dvbt_reed_solomon_dec_0, '0', dl5eu_dvbt_energy_descramble_0, '0']
- [dl5eu_dvbt_tps_decoder_0, '0', blocks_vector_to_stream_2_0, '0']
- [dl5eu_dvbt_tps_decoder_0, '0', dtv_dvbt_demap_0, '0']
- [dl5eu_dvbt_viterbi_decoder_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']
- [dl5eu_mpeg_ts_monitor_0, '0', blocks_file_sink_0, '0']
- [dl5eu_mpeg_ts_monitor_0, '0', network_udp_sink_0, '0']
- [dtv_dvbt_bit_inner_deinterleaver_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_dvbt_convolutional_deinterleaver_0, '0', dl5eu_dvbt_reed_solomon_dec_0, '0']
- [dtv_dvbt_demap_0, '0', dtv_dvbt_symbol_inner_interleaver_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0, '0', dtv_dvbt_bit_inner_deinterleaver_0, '0']
- [iio_pluto_source_0, '0', blocks_selector_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_selector_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_selector_1, '0']
- [rational_resampler_xxx_1, '0', blocks_selector_1, '1']
- [rational_resampler_xxx_2, '0', blocks_selector_1, '2']
- [rational_resampler_xxx_2_0, '0', blocks_selector_1, '3']
- [rational_resampler_xxx_3, '0', blocks_selector_1, '4']
- [rational_resampler_xxx_3_0, '0', blocks_selector_1, '6']
- [rational_resampler_xxx_4, '0', blocks_selector_1, '5']
- [virtual_source_0, '0', dl5eu_dvbt_ofdm_synchronization_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
