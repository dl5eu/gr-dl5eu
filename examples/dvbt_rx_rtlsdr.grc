options:
  parameters:
    author: Ralf DL5EU
    description: DVB-T reception with low bandwidth on 70cm using an RTL-SDR stick
    generate_options: qt_gui
    id: dvbt_rx_rtlsdr
    output_language: python
    title: DVB-T RX with low bandwidth on 70cm
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 1
    label: Center freq.
    min_len: '0'
    rangeType: int
    start: '430000000'
    step: '1000'
    stop: '440000000'
    value: conf_center_freq
    widget: counter
  states: {}
- name: conf_center_freq
  id: variable_config
  parameters:
    config_file: config.ini
    option: center_freq
    section: setup
    type: int
    value: '437000000'
    writeback: center_freq
  states: {}
- name: conf_freq_corr_ppm
  id: variable_config
  parameters:
    config_file: config.ini
    option: freq_corr_ppm
    section: setup
    type: int
    value: '0'
    writeback: freq_corr_ppm
  states: {}
- name: conf_if_gain_db
  id: variable_config
  parameters:
    config_file: config.ini
    option: if_gain_db
    section: setup
    type: int
    value: '10'
    writeback: if_gain_db
  states: {}
- name: conf_rf_gain_db
  id: variable_config
  parameters:
    config_file: config.ini
    option: rf_gain_db
    section: setup
    type: int
    value: '10'
    writeback: rf_gain_db
  states: {}
- name: conf_samp_rate
  id: variable_config
  parameters:
    config_file: config.ini
    option: samp_rate
    section: setup
    type: real
    value: 1000000*8/7
    writeback: samp_rate
  states: {}
- name: freq_corr_ppm
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 1, 1, 1
    label: Freq. ppm
    min_len: '0'
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: conf_freq_corr_ppm
    widget: counter
  states: {}
- name: if_gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 1, 1, 1
    label: IF gain
    min_len: '0'
    rangeType: int
    start: '0'
    step: '1'
    stop: '40'
    value: conf_if_gain_db
    widget: counter
  states: {}
- name: rf_gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    label: RF gain
    min_len: '0'
    rangeType: int
    start: '0'
    step: '1'
    stop: '42'
    value: conf_rf_gain_db
    widget: counter
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 7,0,1,1
    label: Bandwidth
    label0: 200 kHz
    label1: 250 kHz
    label2: 1 MHz
    label3: 2 MHz
    num_opts: '4'
    option0: 200000*8/7
    option1: 250000*8/7
    option2: 1000000*8/7
    option3: 2000000*8/7
    type: real
    value: conf_samp_rate
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '1705'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"superframe_start"'
    name: Superframe before Viterbi Decoder
    type: byte
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"superframe_start"'
    name: Superframe after Viterbi Decoder
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1705'
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: byte
  states: {}
- name: blocks_vector_to_stream_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: complex
  states: {state: disabled}
- name: dl5eu_dvbt_convolutional_deinterleaver_0
  id: dl5eu_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dl5eu_dvbt_ofdm_synchronization_0
  id: dl5eu_dvbt_ofdm_synchronization
  parameters:
    guard_interval: GI_1_4
    interpolate: 'True'
    snr: '10'
    transmission_mode: T2k
  states: {}
- name: dl5eu_dvbt_tps_decoder_0
  id: dl5eu_dvbt_tps_decoder
  parameters:
    print_tps_data: 'True'
    show_ports: 'True'
    transmission_mode: T2k
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C3_4
    constellation: qpsk
    hierarchy: nh
    type: b
  states: {}
- name: dtv_dvbt_bit_inner_deinterleaver_0
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    constellation: qpsk
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_convolutional_deinterleaver_0
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {state: disabled}
- name: dtv_dvbt_demap_0
  id: dtv_dvbt_demap
  parameters:
    constellation: qpsk
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_energy_descramble_0
  id: dtv_dvbt_energy_descramble
  parameters:
    nsize: '8'
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Deinterleave
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_viterbi_decoder_0
  id: dtv_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C3_4
    constellation: qpsk
    hierarchy: nh
    type: b
  states: {state: disabled}
- name: freq_error
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 5,0,1,2
    label1: Freq. error
    max: '10'
    min: '-10'
    name: ''
    type: float
    update_time: '0.25'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 230.0.0.1
    header: '0'
    payloadsize: '1316'
    port: '2000'
    send_eof: 'True'
    type: byte
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0,offset_tune=0,tuner_xtal=28.8e6,rtl_xtal=28.8e6
    bb_gain0: '20'
    bw0: samp_rate
    corr0: freq_corr_ppm
    freq0: center_freq
    gain0: rf_gain_db
    gain_mode0: 'True'
    if_gain0: if_gain_db
    sample_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0, 0, 1, 2
    label1: '" "'
    name: Constellation
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0, 0, 1, 2
    label1: '" "'
    name: OFDM signal
    size: '1024'
    type: complex
    update_time: '0.1'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: samp_error
  id: qtgui_number_sink
  parameters:
    factor1: 1e4
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 6,0,1,2
    label1: Samp. error
    max: '2'
    min: '-2'
    name: ''
    type: float
    update_time: '0.25'
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_tag_debug_0, '0']
- [blocks_vector_to_stream_1, '0', dl5eu_dvbt_viterbi_decoder_0, '0']
- [blocks_vector_to_stream_1, '0', dtv_dvbt_viterbi_decoder_0, '0']
- [blocks_vector_to_stream_2_0, '0', qtgui_const_sink_x_0, '0']
- [dl5eu_dvbt_convolutional_deinterleaver_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '0', blocks_vector_to_stream_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '0', dl5eu_dvbt_tps_decoder_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '1', blocks_null_sink_0_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '2', freq_error, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '3', samp_error, '0']
- [dl5eu_dvbt_tps_decoder_0, '0', blocks_vector_to_stream_2_0, '0']
- [dl5eu_dvbt_tps_decoder_0, '0', dtv_dvbt_demap_0, '0']
- [dl5eu_dvbt_viterbi_decoder_0, '0', blocks_tag_debug_0_0, '0']
- [dl5eu_dvbt_viterbi_decoder_0, '0', dl5eu_dvbt_convolutional_deinterleaver_0, '0']
- [dl5eu_dvbt_viterbi_decoder_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']
- [dtv_dvbt_bit_inner_deinterleaver_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_dvbt_convolutional_deinterleaver_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [dtv_dvbt_demap_0, '0', dtv_dvbt_symbol_inner_interleaver_0, '0']
- [dtv_dvbt_energy_descramble_0, '0', network_udp_sink_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', dtv_dvbt_energy_descramble_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0, '0', dtv_dvbt_bit_inner_deinterleaver_0, '0']
- [dtv_dvbt_viterbi_decoder_0, '0', blocks_tag_debug_0_0, '0']
- [dtv_dvbt_viterbi_decoder_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']
- [osmosdr_source_0, '0', dl5eu_dvbt_ofdm_synchronization_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
