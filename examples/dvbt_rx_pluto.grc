options:
  parameters:
    author: Ralf Gorholt, DL5EU
    copyright: Ralf Gorholt, DL5EU
    description: Receiver for DVB-T signals with low bandwidth using an ADALM PLUTO
    generate_options: qt_gui
    id: dvbt_rx_pluto
    output_language: python
    title: DVB-T-RX with ADALM PLUTO
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 1, 1, 1
    label: Center freq.
    min_len: '0'
    rangeType: int
    start: '430000000'
    step: '100'
    stop: '440000000'
    value: conf_center_freq
    widget: counter
  states: {}
- name: code_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6, 2, 1, 1
    label: Code rate
    labels: '["1/2", "2/3", "3/4", "5/6", "7/8"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4]'
    type: int
    value: conf_code_rate
  states: {}
- name: conf_center_freq
  id: variable_config
  parameters:
    config_file: config_file
    option: center_freq
    section: setup
    type: int
    value: '437000000'
    writeback: center_freq
  states: {}
- name: conf_code_rate
  id: variable_config
  parameters:
    config_file: config_file
    option: code_rate
    section: setup
    type: int
    value: '0'
    writeback: code_rate
  states: {}
- name: conf_decim_select
  id: variable_config
  parameters:
    config_file: config_file
    option: decim_select
    section: setup
    type: int
    value: '1'
    writeback: decim_select
  states: {}
- name: conf_guard_interval
  id: variable_config
  parameters:
    config_file: config_file
    option: guard_interval
    section: setup
    type: int
    value: '0'
    writeback: guard_interval
  states: {}
- name: conf_modulation
  id: variable_config
  parameters:
    config_file: config_file
    option: modulation
    section: setup
    type: int
    value: '0'
    writeback: modulation
  states: {}
- name: conf_rf_gain_db
  id: variable_config
  parameters:
    config_file: config_file
    option: rf_gain_db
    section: setup
    type: int
    value: '64'
    writeback: rf_gain_db
  states: {}
- name: conf_squelch_threshold
  id: variable_config
  parameters:
    config_file: config_file
    option: squelch_threshold
    section: setup
    type: int
    value: '-200'
    writeback: squelch_threshold
  states: {}
- name: config_file
  id: variable
  parameters:
    value: '"config_pluto.ini"'
  states: {}
- name: decim_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5, 1, 1, 1
    label: Bandwidth
    labels: bandwidth_decim_factor.labels()
    num_opts: '0'
    options: bandwidth_decim_factor.indices()
    type: int
    value: conf_decim_select
  states: {}
- name: guard_interval
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5, 2, 1, 1
    label: Guard interval
    labels: '["1/4", "1/8", "1/16", "1/32"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    type: int
    value: conf_guard_interval
  states: {}
- name: modulation
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6, 1, 1, 1
    label: Modulation
    labels: '["QPSK", "16-QAM", "64-QAM"]'
    num_opts: '0'
    options: '[0, 1, 2]'
    type: int
    value: conf_modulation
  states: {}
- name: ofdm_diagnostics
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pluto_sample_rate
  id: variable
  parameters:
    value: bandwidth_decim_factor.PLUTO_SAMPLE_RATE
  states: {}
- name: restart
  id: variable_qtgui_push_button
  parameters:
    label: Restart
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: resync
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 4, 1, 1, 2
    label: Resynchronize
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: rf_gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 1, 1, 1
    label: RF gain
    min_len: '0'
    rangeType: int
    start: '0'
    step: '1'
    stop: '73'
    value: conf_rf_gain_db
    widget: counter
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 2, 1, 1
    label: Squelch
    min_len: '0'
    start: '-200'
    step: '1'
    stop: '200'
    value: conf_squelch_threshold
    widget: counter
  states: {}
- name: sync_sample_rate
  id: variable
  parameters:
    value: bandwidth_decim_factor.sample_rate(decim_select)
  states: {}
- name: bandwidth_decim_factor
  id: epy_module
  parameters:
    source_code: |-
      # Central receiver-bandwidth configuration. Edit only these entries when
      # changing the available bandwidths; update the matching GRC resampler ports.
      PLUTO_SAMPLE_RATE = 2400000
      BANDWIDTHS = (
          ("2 MHz", 20, 21),
          ("1 MHz", 10, 21),
          ("500 kHz", 5, 21),
          ("333 kHz", 160, 1009),
          ("250 kHz", 5, 42),
          ("125 kHz", 5, 84),
          ("66 kHz", 280, 8909),
      )


      def interpolation(index):
          return BANDWIDTHS[int(index)][1]


      def decimation(index):
          return BANDWIDTHS[int(index)][2]


      def sample_rate(index):
          return PLUTO_SAMPLE_RATE * interpolation(index) / decimation(index)


      def labels():
          return [entry[0] for entry in BANDWIDTHS]


      def indices():
          return list(range(len(BANDWIDTHS)))
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '1705'
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '1705'
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '1705'
  states: {}
- name: blocks_null_sink_0_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '1705'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '7'
    output_index: decim_select
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: decim_select
    num_inputs: '7'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    comment: OFDM Guard Interval
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '4'
    output_index: guard_interval
    type: complex
  states: {}
- name: blocks_selector_3
  id: blocks_selector
  parameters:
    comment: OFDM Guard Interval
    enabled: 'True'
    input_index: guard_interval
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
    vlen: '1705'
  states: {}
- name: blocks_selector_3_0
  id: blocks_selector
  parameters:
    comment: Frequency Error
    enabled: 'True'
    input_index: guard_interval
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_4
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: modulation
    type: complex
    vlen: '1512'
  states: {}
- name: blocks_selector_4_0
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: modulation
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: byte
    vlen: '1512'
  states: {}
- name: blocks_selector_5
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: modulation
    type: byte
  states: {}
- name: blocks_selector_5_0
  id: blocks_selector
  parameters:
    comment: Code rate
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '5'
    output_index: code_rate
    type: byte
  states: {}
- name: blocks_selector_5_0_0
  id: blocks_selector
  parameters:
    comment: Code rate
    enabled: 'True'
    input_index: code_rate
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_5_1
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: modulation
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_5_1_0
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: modulation
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_5_1_1
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: modulation
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_5_1_1_0
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: modulation
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_5_1_1_1
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: modulation
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_5_2
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: modulation
    type: byte
  states: {}
- name: blocks_selector_5_3
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: modulation
    type: byte
  states: {}
- name: blocks_selector_5_3_0
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: modulation
    type: byte
  states: {}
- name: blocks_selector_5_3_1
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: modulation
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: byte
  states: {}
- name: blocks_vector_to_stream_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: complex
  states: {}
- name: dl5eu_dvbt_energy_descramble_0
  id: dl5eu_dvbt_energy_descramble
  parameters:
    nsize: '8'
  states: {}
- name: dl5eu_dvbt_ofdm_synchronization_0
  id: dl5eu_dvbt_ofdm_synchronization
  parameters:
    diagnostics: ofdm_diagnostics
    guard_interval: GI_1_4
    interpolate: 'True'
    sample_rate: sync_sample_rate
    snr: '10'
    squelch_db: squelch_threshold
    transmission_mode: T2k
  states: {}
- name: dl5eu_dvbt_ofdm_synchronization_1
  id: dl5eu_dvbt_ofdm_synchronization
  parameters:
    diagnostics: ofdm_diagnostics
    guard_interval: GI_1_8
    interpolate: 'True'
    sample_rate: sync_sample_rate
    snr: '10'
    squelch_db: squelch_threshold
    transmission_mode: T2k
  states: {}
- name: dl5eu_dvbt_ofdm_synchronization_2
  id: dl5eu_dvbt_ofdm_synchronization
  parameters:
    diagnostics: ofdm_diagnostics
    guard_interval: GI_1_16
    interpolate: 'True'
    sample_rate: sync_sample_rate
    snr: '10'
    squelch_db: squelch_threshold
    transmission_mode: T2k
  states: {}
- name: dl5eu_dvbt_ofdm_synchronization_3
  id: dl5eu_dvbt_ofdm_synchronization
  parameters:
    diagnostics: ofdm_diagnostics
    guard_interval: GI_1_32
    interpolate: 'True'
    sample_rate: sync_sample_rate
    snr: '10'
    squelch_db: squelch_threshold
    transmission_mode: T2k
  states: {}
- name: dl5eu_dvbt_reed_solomon_dec_0
  id: dl5eu_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    diagnostics: 'False'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dl5eu_dvbt_tps_decoder_0
  id: dl5eu_dvbt_tps_decoder
  parameters:
    print_tps_data: 'True'
    show_ports: 'True'
    transmission_mode: T2k
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C1_2
    constellation: 64qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_0
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C1_2
    constellation: 16qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_0_0
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C2_3
    constellation: 16qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_0_1
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C3_4
    constellation: 16qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_0_1_0
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C5_6
    constellation: 16qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_0_1_1
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C7_8
    constellation: 16qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_1
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C1_2
    constellation: qpsk
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_1_0
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C2_3
    constellation: qpsk
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_1_1
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C3_4
    constellation: qpsk
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_1_1_0
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C5_6
    constellation: qpsk
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_1_1_1
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C7_8
    constellation: qpsk
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_2
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C2_3
    constellation: 64qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_3
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C3_4
    constellation: 64qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_3_0
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C5_6
    constellation: 64qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dl5eu_dvbt_viterbi_decoder_0_3_1
  id: dl5eu_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C7_8
    constellation: 64qam
    diagnostics: 'False'
    hierarchy: nh
    type: b
  states: {}
- name: dtv_dvbt_bit_inner_deinterleaver_0_0
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    constellation: qpsk
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_bit_inner_deinterleaver_0_0_0
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    constellation: 16qam
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_bit_inner_deinterleaver_0_0_1
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    constellation: 64qam
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_convolutional_deinterleaver_0
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_demap_0_0
  id: dtv_dvbt_demap
  parameters:
    constellation: qpsk
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_demap_0_0_0
  id: dtv_dvbt_demap
  parameters:
    constellation: 16qam
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_demap_0_0_1
  id: dtv_dvbt_demap
  parameters:
    constellation: 64qam
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Deinterleave
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0_0_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Deinterleave
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0_0_1
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Deinterleave
    transmission_mode: T2k
  states: {}
- name: freq_error
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2, 2, 1, 1
    label1: Freq. error
    max: '10000'
    min: '-10000'
    name: ''
    type: float
    unit1: Hz
    update_time: '0.25'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(round(sync_sample_rate))
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: rf_gain_db
    quadrature: 'True'
    rfdc: 'True'
    samplerate: pluto_sample_rate
    type: fc32
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 230.0.0.1
    header: '0'
    payloadsize: '1316'
    port: '2000'
    send_eof: 'True'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1, 0, 8, 1
    label1: '" "'
    legend: 'False'
    name: Constellation
    size: '512'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: pluto_sample_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0, 0, 1, 3
    legend: 'False'
    name: Frequency
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(0)
    interp: bandwidth_decim_factor.interpolation(0)
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(1)
    interp: bandwidth_decim_factor.interpolation(1)
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(2)
    interp: bandwidth_decim_factor.interpolation(2)
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(3)
    interp: bandwidth_decim_factor.interpolation(3)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_4
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(4)
    interp: bandwidth_decim_factor.interpolation(4)
    type: ccc
  states: {}
- name: rational_resampler_xxx_5
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(5)
    interp: bandwidth_decim_factor.interpolation(5)
    type: ccc
  states: {}
- name: rational_resampler_xxx_6
  id: rational_resampler_xxx
  parameters:
    decim: bandwidth_decim_factor.decimation(6)
    interp: bandwidth_decim_factor.interpolation(6)
    taps: ''
    type: ccc
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import os
      import sys
      from PyQt5 import QtCore

      original_set_restart = self.set_restart

      def restart_program():
          self.stop()
          self.wait()

          sys.stdout.flush()
          sys.stderr.flush()

          os.execv(
              sys.executable,
              [sys.executable, os.path.abspath(sys.argv[0]), *sys.argv[1:]]
          )

      def set_restart(value):
          original_set_restart(value)

          if value:
              QtCore.QTimer.singleShot(0, restart_program)

      self.set_restart = set_restart

      synchronizers = (
          self.dl5eu_dvbt_ofdm_synchronization_0,  # 1/4
          self.dl5eu_dvbt_ofdm_synchronization_1,  # 1/8
          self.dl5eu_dvbt_ofdm_synchronization_2,  # 1/16
          self.dl5eu_dvbt_ofdm_synchronization_3,  # 1/32
      )

      original_set_resync = self.set_resync

      def set_resync(value):
          original_set_resync(value)
          if value:
              synchronizers[self.guard_interval].request_resynchronization()

      self.set_resync = set_resync
    section: main_after_init
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: sync_sample_rate
    center_freq: center_freq
    gain: rf_gain_db
    samp_rate: pluto_sample_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: received_samples
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ofdm_symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: received_samples
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ofdm_symbols
  states: {}

connections:
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_1, '0']
- [blocks_selector_0, '2', rational_resampler_xxx_2, '0']
- [blocks_selector_0, '3', rational_resampler_xxx_3, '0']
- [blocks_selector_0, '4', rational_resampler_xxx_4, '0']
- [blocks_selector_0, '5', rational_resampler_xxx_5, '0']
- [blocks_selector_0, '6', rational_resampler_xxx_6, '0']
- [blocks_selector_1, '0', virtual_sink_0, '0']
- [blocks_selector_2, '0', dl5eu_dvbt_ofdm_synchronization_0, '0']
- [blocks_selector_2, '1', dl5eu_dvbt_ofdm_synchronization_1, '0']
- [blocks_selector_2, '2', dl5eu_dvbt_ofdm_synchronization_2, '0']
- [blocks_selector_2, '3', dl5eu_dvbt_ofdm_synchronization_3, '0']
- [blocks_selector_3, '0', virtual_sink_1, '0']
- [blocks_selector_3_0, '0', freq_error, '0']
- [blocks_selector_4, '0', dtv_dvbt_demap_0_0, '0']
- [blocks_selector_4, '1', dtv_dvbt_demap_0_0_0, '0']
- [blocks_selector_4, '2', dtv_dvbt_demap_0_0_1, '0']
- [blocks_selector_4_0, '0', blocks_vector_to_stream_1_0_0, '0']
- [blocks_selector_5, '0', dl5eu_dvbt_viterbi_decoder_0_1, '0']
- [blocks_selector_5, '1', dl5eu_dvbt_viterbi_decoder_0_0, '0']
- [blocks_selector_5, '2', dl5eu_dvbt_viterbi_decoder_0, '0']
- [blocks_selector_5_0, '0', blocks_selector_5, '0']
- [blocks_selector_5_0, '1', blocks_selector_5_2, '0']
- [blocks_selector_5_0, '2', blocks_selector_5_3, '0']
- [blocks_selector_5_0, '3', blocks_selector_5_3_0, '0']
- [blocks_selector_5_0, '4', blocks_selector_5_3_1, '0']
- [blocks_selector_5_0_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']
- [blocks_selector_5_1, '0', blocks_selector_5_0_0, '0']
- [blocks_selector_5_1_0, '0', blocks_selector_5_0_0, '1']
- [blocks_selector_5_1_1, '0', blocks_selector_5_0_0, '2']
- [blocks_selector_5_1_1_0, '0', blocks_selector_5_0_0, '3']
- [blocks_selector_5_1_1_1, '0', blocks_selector_5_0_0, '4']
- [blocks_selector_5_2, '0', dl5eu_dvbt_viterbi_decoder_0_1_0, '0']
- [blocks_selector_5_2, '1', dl5eu_dvbt_viterbi_decoder_0_0_0, '0']
- [blocks_selector_5_2, '2', dl5eu_dvbt_viterbi_decoder_0_2, '0']
- [blocks_selector_5_3, '0', dl5eu_dvbt_viterbi_decoder_0_1_1, '0']
- [blocks_selector_5_3, '1', dl5eu_dvbt_viterbi_decoder_0_0_1, '0']
- [blocks_selector_5_3, '2', dl5eu_dvbt_viterbi_decoder_0_3, '0']
- [blocks_selector_5_3_0, '0', dl5eu_dvbt_viterbi_decoder_0_1_1_0, '0']
- [blocks_selector_5_3_0, '1', dl5eu_dvbt_viterbi_decoder_0_0_1_0, '0']
- [blocks_selector_5_3_0, '2', dl5eu_dvbt_viterbi_decoder_0_3_0, '0']
- [blocks_selector_5_3_1, '0', dl5eu_dvbt_viterbi_decoder_0_1_1_1, '0']
- [blocks_selector_5_3_1, '1', dl5eu_dvbt_viterbi_decoder_0_0_1_1, '0']
- [blocks_selector_5_3_1, '2', dl5eu_dvbt_viterbi_decoder_0_3_1, '0']
- [blocks_vector_to_stream_1_0_0, '0', blocks_selector_5_0, '0']
- [blocks_vector_to_stream_2_0, '0', qtgui_const_sink_x_0, '0']
- [dl5eu_dvbt_energy_descramble_0, '0', network_udp_sink_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '0', blocks_selector_3, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '1', blocks_null_sink_0_0_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_0, '2', blocks_selector_3_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_1, '0', blocks_selector_3, '1']
- [dl5eu_dvbt_ofdm_synchronization_1, '1', blocks_null_sink_0_0_0_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_1, '2', blocks_selector_3_0, '1']
- [dl5eu_dvbt_ofdm_synchronization_2, '0', blocks_selector_3, '2']
- [dl5eu_dvbt_ofdm_synchronization_2, '1', blocks_null_sink_0_0_0_1, '0']
- [dl5eu_dvbt_ofdm_synchronization_2, '2', blocks_selector_3_0, '2']
- [dl5eu_dvbt_ofdm_synchronization_3, '0', blocks_selector_3, '3']
- [dl5eu_dvbt_ofdm_synchronization_3, '1', blocks_null_sink_0_0, '0']
- [dl5eu_dvbt_ofdm_synchronization_3, '2', blocks_selector_3_0, '3']
- [dl5eu_dvbt_reed_solomon_dec_0, '0', dl5eu_dvbt_energy_descramble_0, '0']
- [dl5eu_dvbt_tps_decoder_0, '0', blocks_selector_4, '0']
- [dl5eu_dvbt_tps_decoder_0, '0', blocks_vector_to_stream_2_0, '0']
- [dl5eu_dvbt_viterbi_decoder_0, '0', blocks_selector_5_1, '2']
- [dl5eu_dvbt_viterbi_decoder_0_0, '0', blocks_selector_5_1, '1']
- [dl5eu_dvbt_viterbi_decoder_0_0_0, '0', blocks_selector_5_1_0, '1']
- [dl5eu_dvbt_viterbi_decoder_0_0_1, '0', blocks_selector_5_1_1, '1']
- [dl5eu_dvbt_viterbi_decoder_0_0_1_0, '0', blocks_selector_5_1_1_0, '1']
- [dl5eu_dvbt_viterbi_decoder_0_0_1_1, '0', blocks_selector_5_1_1_1, '1']
- [dl5eu_dvbt_viterbi_decoder_0_1, '0', blocks_selector_5_1, '0']
- [dl5eu_dvbt_viterbi_decoder_0_1_0, '0', blocks_selector_5_1_0, '0']
- [dl5eu_dvbt_viterbi_decoder_0_1_1, '0', blocks_selector_5_1_1, '0']
- [dl5eu_dvbt_viterbi_decoder_0_1_1_0, '0', blocks_selector_5_1_1_0, '0']
- [dl5eu_dvbt_viterbi_decoder_0_1_1_1, '0', blocks_selector_5_1_1_1, '0']
- [dl5eu_dvbt_viterbi_decoder_0_2, '0', blocks_selector_5_1_0, '2']
- [dl5eu_dvbt_viterbi_decoder_0_3, '0', blocks_selector_5_1_1, '2']
- [dl5eu_dvbt_viterbi_decoder_0_3_0, '0', blocks_selector_5_1_1_0, '2']
- [dl5eu_dvbt_viterbi_decoder_0_3_1, '0', blocks_selector_5_1_1_1, '2']
- [dtv_dvbt_bit_inner_deinterleaver_0_0, '0', blocks_selector_4_0, '0']
- [dtv_dvbt_bit_inner_deinterleaver_0_0_0, '0', blocks_selector_4_0, '1']
- [dtv_dvbt_bit_inner_deinterleaver_0_0_1, '0', blocks_selector_4_0, '2']
- [dtv_dvbt_convolutional_deinterleaver_0, '0', dl5eu_dvbt_reed_solomon_dec_0, '0']
- [dtv_dvbt_demap_0_0, '0', dtv_dvbt_symbol_inner_interleaver_0_0, '0']
- [dtv_dvbt_demap_0_0_0, '0', dtv_dvbt_symbol_inner_interleaver_0_0_0, '0']
- [dtv_dvbt_demap_0_0_1, '0', dtv_dvbt_symbol_inner_interleaver_0_0_1, '0']
- [dtv_dvbt_symbol_inner_interleaver_0_0, '0', dtv_dvbt_bit_inner_deinterleaver_0_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0_0_0, '0', dtv_dvbt_bit_inner_deinterleaver_0_0_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0_0_1, '0', dtv_dvbt_bit_inner_deinterleaver_0_0_1, '0']
- [iio_pluto_source_0, '0', blocks_selector_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_selector_1, '0']
- [rational_resampler_xxx_1, '0', blocks_selector_1, '1']
- [rational_resampler_xxx_2, '0', blocks_selector_1, '2']
- [rational_resampler_xxx_3, '0', blocks_selector_1, '3']
- [rational_resampler_xxx_4, '0', blocks_selector_1, '4']
- [rational_resampler_xxx_5, '0', blocks_selector_1, '5']
- [rational_resampler_xxx_6, '0', blocks_selector_1, '6']
- [soapy_plutosdr_source_0, '0', blocks_selector_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', blocks_selector_2, '0']
- [virtual_source_1, '0', dl5eu_dvbt_tps_decoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
